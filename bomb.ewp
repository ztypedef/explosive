# IAR project bomb.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100x4 ST STM32F100x4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F10X_LD_VL; USE_STDPERIPH_DRIVER; USE_STM32F100
  ICCARM.CCIncludePath2: src; src\fat_sd; CMSIS\CM3\DeviceSupport\ST\STM32F10x; STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bomb.srec
  ILINK.IlinkOutputFile: bomb.out
  ILINK.IlinkIcfFile: bomb.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_ld_vl.s
    CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Preipheral_lib
    STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group src
    src/: buart.c button.c evaluator.c main.c
    STM32F10x_StdPeriph_Driver/src/: stm32f10x_rtc.c stm32f10x_spi.c
  group src/fs
    src/fat_sd/: fattime.c ff.c sd_spi_stm32.c
  group src/fs/unicode
    src/fat_sd/option/: ccsbcs.c
